# IAR project NJUST.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; DEBUG; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SDK_I2C_BASED_COMPONENT_USED=1; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: fsl_lib; driver; system; driver\camera; driver\motor; system\startup; system\core; car; car\control; car\image; system\xip; system\utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: NJUST.srec
  ILINK.IlinkOutputFile: NJUST.out
  ILINK.IlinkIcfFile: IDEfiles\sdram_boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LQRELEASE; DEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; XIP_EXTERNAL_FLASH=1; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SDK_I2C_BASED_COMPONENT_USED=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCOptLevel: 1
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: NJUST.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkKeepSymbols: image_vector_table; boot_data; dcd_data
  ILINK.IlinkConfigDefines: __stack_size__=0x8000; __heap_size__=0x100000
  ILINK.IlinkIcfFile: IDEfiles\qspi_boot.icf
configuration NJUSTsmartcar (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: fsl_lib; driver; system; driver\camera; driver\motor; system\startup; system\core; car; car\control; car\image; system\spiflash; system\utilities; user
  ICCARM.CCOptLevel: 1
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: NJUST.bin
  ILINK.IlinkOutputFile: NJUST.bin
  ILINK.IlinkKeepSymbols: image_vector_table; boot_data; dcd_data
  ILINK.IlinkConfigDefines: __stack_size__=0x8000; __heap_size__=0x100000
  ILINK.IlinkIcfFile: IDEfiles\qspi_boot.icf
  group car
    car/: direction.c direction.h speed.c speed.h status.c status.h test.c test.h userinterface.c userinterface.h
  group doc
    user/: readme.txt user keyword.txt
  group driver
    driver/: adc.c adc.h ANO_DT.c ANO_DT.h extern_interrupt.c extern_interrupt.h gpt.c gpt.h iic.c iic.h key.c key.h led.c led.h nrf2401.c nrf2401.h oled.c oled.h pad_config.h pit.c pit.h spi.c spi.h uart.c uart.h wdog.c wdog.h
  group driver/image
    driver/camera/: csi.c csi.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h getimage.c getimage.h img_calculate.c img_calculate.h mt9v034.c mt9v034.h
  group driver/motor
    driver/motor/: encoder.c encoder.h motor_pid.c motor_pid.h pwm.c pwm.h
  group fsl_lib
    fsl_lib/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_enc.c fsl_enc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h
  group system
    system/: board.c board.h clock_config.c clock_config.h fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system.c system.h
  group system/spiflash
    system/spiflash/: external_flash_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h spiflash_config.c
  group system/startup
    system/startup/: startup_MIMXRT1052.s system_MIMXRT1052.c system_MIMXRT1052.h
  group user
    user/: CodeStyle.c CodeStyle.h main.c
